# Keil uVision project zadajak.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: zadajak +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./: main.cpp
  group OLED
    ./: fonts.c fonts.h ssd1306.c ssd1306.h ssd1306_i2c.c ssd1306_i2c.h
  group DriverSTM
    ./: driver.h drivermain.cpp
  group Dzojstik
    ./: dzojstik.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
